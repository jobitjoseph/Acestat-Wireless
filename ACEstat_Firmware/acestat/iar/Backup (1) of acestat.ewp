# IAR project Backup (1) of acestat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM355 AnalogDevices ADuCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355
  ICCARM.CCIncludePath2: ..\..\aducm355-examples\inc; ..\..\aducm355-examples\common; ..\..\aducm355-examples\common\ad5940lib; ..\..\aducm355-examples\examples\ApplicationExamples\M355_ECSns_EIS; ..\src; ..\src\chemcrab_lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: acestat.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: bootloader; __checksum
  ILINK.IlinkIcfFile: ADuCM355_SRAM_Mode2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group application
    ../src/: BootloaderConstantArray.c main.c
  group application/ACEstat_lib
    ../src/chemcrab_lib/: ACEstat_adc.c ACEstat_adc.h ACEstat_cleaning.c ACEstat_cleaning.h ACEstat_eis.c ACEstat_eis.h ACEstat_gpt.c ACEstat_gpt.h ACEstat_interface.c ACEstat_interface.h ACEstat_inthandlers.c ACEstat_inthandlers.h ACEstat_misc.c ACEstat_misc.h ACEstat_mux.c ACEstat_mux.h ACEstat_setup.c ACEstat_setup.h ACEstat_tia.c ACEstat_tia.h ACEstat_voltammetry.c ACEstat_voltammetry.h
  group application/separate
    ../src/: AfeAdcLib.c AfeDacLib.c AfeTiaLib.c
  group common
    ../../aducm355-examples/common/ad5940lib/: ad5940.c
    ../../aducm355-examples/common/: ADuCM355Port.c AfeWdtLib.c ClkLib.c CrcLib.c DioLib.c DmaLib.c FeeLib.c GptLib.c I2cLib.c IntLib.c PwrLib.c RstLib.c RtcLib.c SpiLib.c UrtLib.c
    ../../aducm355-examples/examples/ApplicationExamples/M355_ECSns_EIS/: Impedance.c
  group startup
    ../../aducm355-examples/common/IAR/: retarget.c
    ./: startup_ADuCM355_bootloader.c
    ../../aducm355-examples/common/: system_ADuCM355.c
