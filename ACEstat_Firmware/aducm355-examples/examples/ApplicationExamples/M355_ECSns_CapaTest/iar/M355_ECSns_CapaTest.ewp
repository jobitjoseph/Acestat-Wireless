# IAR project M355_ECSns_CapaTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355
  ICCARM.CCIncludePath2: ..\..\..\..\common; ..\..\..\..\inc; ..\..\..\..\common\ad5940lib; ..\..\..\..\common\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: M355_AirQual.out
  ILINK.IlinkIcfFile: ..\ADuCM355_SRAM_Mode2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../: AD5940Main.c ChronoAmperometric.c main.c
  group common
    ../../../../common/ad5940lib/: ad5940.c
    ../../../../common/: ADuCM355Port.c ClkLib.c DioLib.c IntLib.c RstLib.c UrtLib.c
  group startup
    ../../../../common/IAR/: retarget.c startup_ADuCM355.c
    ../../../../common/: system_ADuCM355.c
