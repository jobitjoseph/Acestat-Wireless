# IAR project M355_Uart_Wakeup.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355
  ICCARM.CCIncludePath2: ../../../../common; ../../../../inc; ..\..\..\..\common\ad5940lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: M355_Uart_FIFO.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: M355_UART_Wakeup.c
  group Common
    ../../../../common/ad5940lib/: ad5940.c
    ../../../../common/: ADuCM355Port.c ClkLib.c DioLib.c IntLib.c PwrLib.c UrtLib.c
  group Startup
    ../../../../common/IAR/: retarget.c startup_ADuCM355.c
    ../../../../common/: system_ADuCM355.c
