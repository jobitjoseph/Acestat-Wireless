# IAR project M355_Example_Application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355
  ICCARM.CCIncludePath2: ..\..\..\..\inc; ..\..\..\..\common; ..\..\..\..\common\ad5940lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: M355_CRC.srec
  ILINK.IlinkOutputFile: M355_CRC.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: user-bootloader-sample-application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../: BootloaderConstantArray.c M355_BootloaderApp.c
  group common
    ../../../../common/ad5940lib/: ad5940.c
    ../../../../common/: ClkLib.c CrcLib.c DioLib.c UrtLib.c
  group startup
    ../../../../common/IAR/: retarget.c
    ../: startup_ADuCM355_Bootloader.c
    ../../../../common/: system_ADuCM355.c
